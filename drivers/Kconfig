## drivers/Kconfig
```kconfig
# Copyright (c) 2026 IAR Systems AB
# SPDX-License-Identifier: Apache-2.0

menu "Drivers"
rsource "blink/Kconfig"
rsource "button/Kconfig"
endmenu
```
